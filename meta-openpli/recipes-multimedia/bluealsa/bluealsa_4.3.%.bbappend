# https://github.com/openembedded/meta-openembedded/commit/1a9744b3cabd440ff0cece448a3b9717da8cfd97

FILES:${PN}-staticdev += "${libdir}/alsa-lib/*.a"
