require oscam-common.inc

SRC_ORIGIN ?= "gitsm://git.streamboard.tv/common/oscam.git;protocol=https;branch=master"

CAMTITLE = "OSCam ${PV}: Open Source Softcam"
CAMNAME = "oscam"
